# Keil uVision project PWM.uvprojx, settings and files
target template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temlate +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\H\1602;..\SYSTERM\delay;..\SYSTERM\exti;..\SYSTERM\key;..\SYSTERM\led;..\SYSTERM\sys;..\SYSTERM\usart;..\USER;..\H\timer;..\STM32F10x_FWLib\inc;..\H\beep;..\H\TPAD;..\H\pwm;..\H\FreeRTOS\include;..\H\FreeRTOS\portable\RVDS\ARM_CM3;..\H\IIC;..\H\OLED;..\H\pwm;..\H\flash;..\H
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTERM
    ../SYSTERM/delay/: delay.c
    ../SYSTERM/sys/: sys.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
    ../H/FreeRTOS/portable/MemMang/: heap_4.c
    ../H/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../H/FreeRTOS/Ser/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../H/IIC/: algorithm.c max30102.c myiic.c
    ../H/OLED/: oled.c
    ../H/pwm/: pwm.c
    ../SYSTERM/usart/: usart.c
    ../H/flash/: stmflash.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
