# Keil uVision project PWM.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: temlate +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\H\1602;..\SYSTERM\delay;..\SYSTERM\exti;..\SYSTERM\key;..\SYSTERM\led;..\SYSTERM\sys;..\SYSTERM\usart;..\USER;..\H\timer;..\STM32F10x_FWLib\inc;..\H\beep;..\H\TPAD;..\H\pwm;..\H\flash
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTERM
    ../SYSTERM/delay/: delay.c
    ../SYSTERM/sys/: sys.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c
    ../H/flash/: stmflash.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group H
    ../H/pwm/: pwm.c
